## Config.in
```kconfig
config BR2_PACKAGE_CHROMASENSE
	bool "chromasense"
	help
	  A guitar tuner LV2 plugin, ported from the Guitarix project.

	  https://github.com/theKAOSSphere/chromasense
```
